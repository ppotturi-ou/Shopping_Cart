# Keil uVision project Shopping_Cart.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Shopping_Cart
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;.\Drivers;.\Middleware
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Smart_Shopping_Cart_Client
    ./: main.c Shopping_list_struct.c
  group Middleware
    ./Middleware/: Barcode_Driver.c WiFi_Driver.c lcd.c
  group Drivers
    ./Drivers/: GPIO.c I2C.c WiFi_UART.c Barcode_UART.c queue.c delay.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.5.0
